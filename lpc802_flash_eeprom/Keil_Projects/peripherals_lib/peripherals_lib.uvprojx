# Keil uVision project peripherals_lib.uvprojx, settings and files
target flash (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: peripherals_lib (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\Source_Code\peripherals_lib\inc; ..\..\Source_Code\utilities_lib\inc; ..\..\Source_Code\common\inc
  memory RVCT4: ROM 0x0 size 0x800
  memory RVCT9: RAM 0x10000000 size 0x800
  group src
    ../../Source_Code/peripherals_lib/src/: syscon.c swm.c gpio.c i2c.c
  group inc
    ../../Source_Code/peripherals_lib/inc/: acomp.h adc.h fro.h gpio.h i2c.h iocon.h mrt.h pmu.h spi.h swm.h syscon.h uart.h wkt.h wwdt.h
