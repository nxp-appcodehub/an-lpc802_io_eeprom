# Keil uVision project flash_test.uvprojx, settings and files
target flash_lpc802_eeporm_firmware (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC811M001JDH16 NXP
  pack: NXP.LPC811_DFP.13.0.0
  cpu: IROM(0x00000000,0x00002000) IRAM(0x10000000,0x00000800) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: UART0_Terminal
  AfterMake: $KARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x0)
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: LPC802
  c include: ..\..\Source_Code\peripherals_lib\inc;..\..\Source_Code\utilities_lib\inc;..\..\Source_Code\common\inc;..\..\Source_Code\flash_eeporm\inc;..\..\Source_Code\flash_eeporm\src\structures;..\..\Source_Code\flash_eeporm\src
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x10000000 size 0x800
  group src
    ../../Source_Code/common/src/: Keil_startup.s system.c
    ../../Source_Code/flash_eeporm/src/: flash.c main.c common.c
    ../../Source_Code/flash_eeporm/inc/: app.h
  group drivers
    ../../Source_Code/peripherals_lib/src/: gpio.c i2c.c swm.c syscon.c uart.c
  group utilities
    ../../Source_Code/utilities_lib/src/: utilities.c
  group structures
    ../../Source_Code/flash_eeporm/src/structures/: mq.c
